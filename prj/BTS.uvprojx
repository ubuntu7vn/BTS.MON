# Keil uVision project BTS.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BTS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: .\FreeRTOS\include;.\FreeRTOS\ARM_CM4F;.\FreeRTOS\CMSIS_RTOS;.\sysConfig;.\FreeRTOS;.\Applications;.\Middlewares\STM32_USB_host_Library\Class\CDC\Inc;.\Middlewares\STM32_USB_host_Library\Core\Inc;.\unittest;.\Middlewares\mosquitto-1.4.10\lib;.\Middlewares\LwIP\system\arch;.\Middlewares\LwIP\system\OS;.\Middlewares\LwIP\src\include\lwip;.\Middlewares\LwIP\src\include\netif;.\Middlewares\LwIP\src\include\posix;.\Middlewares\LwIP\src\include\posix\sys;.\Middlewares\LwIP\src\include;.\Middlewares\LwIP\system
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_4.c list.c queue.c tasks.c timers.c
  group ARM_CM4F
    ./FreeRTOS/ARM_CM4F/: port.c portmacro.h
  group cmsis_os
    ./FreeRTOS/CMSIS_RTOS/: cmsis_os.c cmsis_os.h
  group unittest
    ./unittest/: os_test.c usb_test.c lwip_test.c mqtt_test.c unittest.h
  group os_include
    ./FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h stdint.readme task.h timers.h
  group sys_config
    ./sysConfig/: FreeRTOSConfig.h lwipopts.h
  group main
    ./: main.c
  group Mid/usb/host/core
    ./Middlewares/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Mid/usb/host/class
    ./Middlewares/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
  group App/usb
    ./Applications/: usbh_conf.c
  group Mid/mqtt
    ./Middlewares/mosquitto-1.4.10/lib/: logging_mosq.c memory_mosq.c messages_mosq.c mosquitto.c net_mosq.c read_handle.c read_handle_client.c read_handle_shared.c send_client_mosq.c send_mosq.c socks_mosq.c srv_mosq.c thread_mosq.c time_mosq.c tls_mosq.c util_mosq.c will_mosq.c
  group Mid/lwip/core
    ./Middlewares/LwIP/src/core/: def.c dns.c inet_chksum.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group Mid/lwip/api
    ./Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
  group Mid/lwip/netif
    ./Middlewares/LwIP/src/netif/: etharp.c ethernetif.c slipif.c
  group Mid/lwip/port
    ./Middlewares/LwIP/system/OS/: sys_arch.c
  group Mid/lwip/core/ipv4
    ./Middlewares/LwIP/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
  group Device
    ./RTE/Device/STM32F407VGTx/: stm32f4xx_it.c
  group Board/BTSMon_v1.0
    ./Board/: BtsMonV1.0.c
  group App/tasks
    ./Applications/: tsk_button.c
software components: CMSIS:CORE 4.3.0, Device:STM32Cube Framework:Classic 1.4.0, Device:STM32Cube HAL:ADC 1.4.0, Device:STM32Cube HAL:CAN 1.4.0, Device:STM32Cube HAL:CRC 1.4.0, Device:STM32Cube HAL:Common 1.4.0, Device:STM32Cube HAL:Cortex 1.4.0, Device:STM32Cube HAL:DMA 1.4.0, Device:STM32Cube HAL:ETH 1.4.0, Device:STM32Cube HAL:Flash 1.4.0, Device:STM32Cube HAL:GPIO 1.4.0, Device:STM32Cube HAL:IWDG 1.4.0, Device:STM32Cube HAL:PWR 1.4.0, Device:STM32Cube HAL:RCC 1.4.0, Device:STM32Cube HAL:RTC 1.4.0, Device:STM32Cube HAL:SPI 1.4.0, Device:STM32Cube HAL:TIM 1.4.0, Device:STM32Cube HAL:UART 1.4.0, Device:STM32Cube HAL:USART 1.4.0, Device:STM32Cube HAL:WWDG 1.4.0, Device:Startup 2.4.0
